# Keil uVision project STC32G-LIB.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: STC32G-LIB +hex
  link misc: REMOVEUNUSED
  group User
    ../User/: main.c system_init.c Task.c isr.asm uart.c tongxin.c tongxin2.c func.c
  group APP
    ../App/src/: APP.c APP_Lamp.c
  group Driver
    ../Driver/src/: STC32G_ADC.c STC32G_Compare.c STC32G_Delay.c STC32G_EEPROM.c STC32G_Exti.c STC32G_GPIO.c STC32G_I2C.c STC32G_LCM.c STC32G_NVIC.c STC32G_Soft_I2C.c STC32G_Soft_UART.c STC32G_SPI.c STC32G_Timer.c STC32G_UART.c STC32G_WDT.c STC32G_DMA.c STC32G_PWM.c STC32G_RTC.c STC32G_CAN.c STC32G_LIN.c STC32G_Clock.c STC32G_USART_LIN.c
  group ISR
    ../Driver/isr/: STC32G_ADC_Isr.c STC32G_Compare_Isr.c STC32G_Exti_Isr.c STC32G_GPIO_Isr.c STC32G_I2C_Isr.c STC32G_SPI_Isr.c STC32G_Timer_Isr.c STC32G_UART_Isr.c STC32G_DMA_Isr.c STC32G_PWM_Isr.c STC32G_RTC_Isr.c STC32G_LCM_Isr.c STC32G_CAN_Isr.c STC32G_LIN_Isr.c
  group LIB
    ../Driver/lib/: STC32_MDU32_V1.1.LIB
